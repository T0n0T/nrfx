# Keil uVision project nrf52840.uvprojx, settings and files
target rtthread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: IRAM(0x20000000,0x40000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, SOFTDEVICE_PRESENT, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, NRF52840_XXAA, __RTTHREAD__, CONFIG_GPIO_AS_PINRESET
  c misc: --reduce_paths
  c include: packages\nrf5x_sdk-latest\components\ble\nrf_ble_scan;rt-thread\components\legacy;packages\nrfx-latest\hal;rt-thread\components\drivers\include;packages\nrfx-latest\drivers\src;packages\nrf5x_sdk-latest\components\softdevice\common;packages\nrf5x_sdk-latest\components\ble\ble_link_ctx_manager;libraries\drivers;packages\nrfx-latest\drivers;packages\nrf5x_sdk-latest\components\libraries\sortlist;packages\nrf5x_sdk-latest\components\softdevice\s140\headers\nrf52;packages\nrf5x_sdk-latest\components\libraries\atomic_fifo;board;packages\nrf5x_sdk-latest\components\ble\ble_db_discovery;packages\nrf5x_sdk-latest\components\libraries\atomic;rt-thread\libcpu\arm\common;packages\nrf5x_sdk-latest\components\softdevice\s140\headers;packages\nrf5x_sdk-latest\components\libraries\log;packages\nrf5x_sdk-latest\components\libraries\ringbuf;packages\nrf5x_sdk-latest\components\libraries\queue;packages\nrfx-latest;packages\nrf5x_sdk-latest\components\libraries\util;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\libc\posix\io\poll;rt-thread\components\drivers\spi;packages\nrf5x_sdk-latest\components\ble\nrf_ble_qwr;packages\nrf5x_sdk-latest\components\libraries\fifo;rt-thread\components\libc\compilers\common\extension;rt-thread\components\libc\posix\io\stdio;packages\nrf5x_sdk-latest\components\ble\nrf_ble_gq;rt-thread\components\drivers\include;packages\nrf5x_sdk-latest\components\ble\ble_advertising;packages\nrf5x_sdk-latest\components\libraries\log\src;rt-thread\components\libc\compilers\common\include;packages\nrf5x_sdk-latest\components\libraries\experimental_section_vars;packages\nrf5x_sdk-latest\components\libraries\atomic_flags;packages\nrf5x_sdk-latest\components\libraries\memobj;.;packages\nrfx-latest\drivers\include;rt-thread\include;packages\nrf5x_sdk-latest\components\ble\nrf_ble_gatt;applications;packages\nrf5x_sdk-latest\components\libraries\strerror;packages\nrf5x_sdk-latest\components\ble\ble_services\ble_nus;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\components\drivers\include;packages\nrfx-latest\mdk;packages\nrf5x_sdk-latest\components\libraries\scheduler;rt-thread\components\drivers\include;rt-thread\components\finsh;rt-thread\components\drivers\include;packages\nrf5x_sdk-latest\components\ble\common;rt-thread\components\drivers\include;packages\nrf5x_sdk-latest\integration\nrfx\legacy;packages\nrf5x_sdk-latest\components\libraries\balloc;packages\nrf5x_sdk-latest\components\libraries\hardfault;packages\nrf5x_sdk-latest\components\libraries\sensorsim;rt-thread\components\libc\posix\ipc;libraries\cmsis\include;packages\CmBacktrace-v1.4.1;packages\nrf5x_sdk-latest\components\libraries\timer;rt-thread\components\drivers\include
  memory RVCT4: ROM 0x27000 size 0xd9000
  memory RVCT9: RAM 0x20002ae8 size 0x3d518
  group Applications
    applications/: application.c
  group cm_backtrace
    packages/CmBacktrace-v1.4.1/: cm_backtrace.c cmb_port.c cmb_flash_log.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/rtc/: rtc.c
    rt-thread/components/drivers/sensor/v1/: sensor.c sensor_cmd.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi-bit-ops.c spi_core.c spi_dev.c
  group Drivers
    board/: board.c
    libraries/drivers/: drv_gpio.c drv_i2c.c drv_rtc.c drv_spi.c drv_uart.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Legacy
    rt-thread/components/legacy/ipc/: workqueue_legacy.c
  group nRF_BLE
    packages/nrf5x_sdk-latest/components/ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
    packages/nrf5x_sdk-latest/components/ble/nrf_ble_gq/: nrf_ble_gq.c
    packages/nrf5x_sdk-latest/components/ble/common/: ble_conn_state.c ble_srv_common.c ble_advdata.c
    packages/nrf5x_sdk-latest/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    packages/nrf5x_sdk-latest/components/ble/ble_advertising/: ble_advertising.c
    packages/nrf5x_sdk-latest/components/ble/ble_db_discovery/: ble_db_discovery.c
    packages/nrf5x_sdk-latest/components/ble/nrf_ble_scan/: nrf_ble_scan.c
    packages/nrf5x_sdk-latest/rtt_adapter/: ble_conn_params_rtt.c
    packages/nrf5x_sdk-latest/components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
    packages/nrf5x_sdk-latest/integration/nrfx/legacy/: nrf_drv_clock.c
  group nRF_BLE_Services
    packages/nrf5x_sdk-latest/components/ble/ble_services/ble_nus/: ble_nus.c
    packages/nrf5x_sdk-latest/rtt_adapter/: ble_app_uart.c
  group nrf_Drivers
    packages/nrfx-latest/drivers/src/: nrfx_power.c nrfx_spis.c nrfx_qspi.c nrfx_twi.c nrfx_pwm.c nrfx_saadc.c nrfx_egu.c nrfx_ppi.c nrfx_pdm.c nrfx_usbd.c nrfx_lpcomp.c nrfx_spi.c nrfx_nfct.c nrfx_nvmc.c nrfx_rng.c nrfx_rtc.c nrfx_gpiote.c nrfx_uarte.c nrfx_twim.c nrfx_comp.c nrfx_spim.c nrfx_dppi.c nrfx_timer.c nrfx_qdec.c nrfx_systick.c nrfx_wdt.c nrfx_adc.c nrfx_clock.c nrfx_usbreg.c nrfx_twi_twim.c nrfx_twis.c nrfx_i2s.c nrfx_uart.c nrfx_ipc.c nrfx_temp.c
    packages/nrfx-latest/mdk/: arm_startup_nrf52840.s system_nrf52840.c
  group nRF_Libraries
    packages/nrf5x_sdk-latest/components/libraries/util/: app_error_weak.c app_util_platform.c nrf_assert.c app_error.c app_error_handler_keil.c
    packages/nrf5x_sdk-latest/components/libraries/scheduler/: app_scheduler.c
    packages/nrf5x_sdk-latest/components/libraries/sortlist/: nrf_sortlist.c
    packages/nrf5x_sdk-latest/components/libraries/strerror/: nrf_strerror.c
    packages/nrf5x_sdk-latest/components/libraries/fifo/: app_fifo.c
    packages/nrf5x_sdk-latest/components/libraries/experimental_section_vars/: nrf_section_iter.c
    packages/nrf5x_sdk-latest/components/libraries/balloc/: nrf_balloc.c
    packages/nrf5x_sdk-latest/components/libraries/sensorsim/: sensorsim.c
    packages/nrf5x_sdk-latest/components/libraries/atomic_flags/: nrf_atflags.c
    packages/nrf5x_sdk-latest/components/libraries/queue/: nrf_queue.c
    packages/nrf5x_sdk-latest/components/libraries/memobj/: nrf_memobj.c
    packages/nrf5x_sdk-latest/components/libraries/atomic/: nrf_atomic.c
    packages/nrf5x_sdk-latest/components/libraries/hardfault/: hardfault_implementation.c
    packages/nrf5x_sdk-latest/components/libraries/atomic_fifo/: nrf_atfifo.c
    packages/nrf5x_sdk-latest/components/libraries/ringbuf/: nrf_ringbuf.c
  group nRF_SoftDevice
    packages/nrf5x_sdk-latest/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
target softdevice (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: as above
  output: s140_nrf52_7.0.1_softdevice.hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NRF52840_XXAA, USE_APP_CONFIG, RT_USING_ARM_LIBC  APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  asm define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192
  asm misc: --cpreproc_opts=-DAPP_TIMER_V2,-DAPP_TIMER_V2_RTC1_ENABLED,-DBOARD_PCA10056,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52840_XXAA,-DNRF_SD_BLE_API_VERSION=7,-DS140,-DSOFTDEVICE_PRESENT,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  memory RVCT4: ROM 0x27000 size 0xd9000
  memory RVCT9: RAM 0x20002300 size 0x40000
  link misc: --diag_suppress 6330
