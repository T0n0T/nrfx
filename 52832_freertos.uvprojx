# Keil uVision project 52832_freertos.uvprojx, settings and files
target 52832_freertos (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x00800000,0x00010000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: 52832_freertos
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: CONFIG_GPIO_AS_PINRESET,FLOAT_ABI_HARD,FREERTOS,NRF52,NRF52832_XXAA,NRF52_PAN_74,NRF_SD_BLE_API_VERSION=7,S132,SOFTDEVICE_PRESENT,__HEAP_SIZE=1024,__STACK_SIZE=2048,BOARD_CUSTOM,USE_APP_CONFIG,AT_USING_CLIENT,MQTT_NETWORK_TYPE_NO_TLS,BLE_ADDR="{0x66, 0x55, 0x44, 0x33, 0x22, 0x11}"
  c include: nrf_sdk\components;nrf_sdk\components\ble\ble_advertising;nrf_sdk\components\ble\ble_dtm;nrf_sdk\components\ble\ble_racp;nrf_sdk\components\ble\ble_services\ble_ancs_c;nrf_sdk\components\ble\ble_services\ble_ans_c;nrf_sdk\components\ble\ble_services\ble_bas;nrf_sdk\components\ble\ble_services\ble_bas_c;nrf_sdk\components\ble\ble_services\ble_cscs;nrf_sdk\components\ble\ble_services\ble_cts_c;nrf_sdk\components\ble\ble_services\ble_dfu;nrf_sdk\components\ble\ble_services\ble_dis;nrf_sdk\components\ble\ble_services\ble_gls;nrf_sdk\components\ble\ble_services\ble_hids;nrf_sdk\components\ble\ble_services\ble_hrs;nrf_sdk\components\ble\ble_services\ble_hrs_c;nrf_sdk\components\ble\ble_services\ble_hts;nrf_sdk\components\ble\ble_services\ble_ias;nrf_sdk\components\ble\ble_services\ble_ias_c;nrf_sdk\components\ble\ble_services\ble_lbs;nrf_sdk\components\ble\ble_services\ble_lbs_c;nrf_sdk\components\ble\ble_services\ble_lls;nrf_sdk\components\ble\ble_services\ble_nus;nrf_sdk\components\ble\ble_services\ble_nus_c;nrf_sdk\components\ble\ble_services\ble_rscs;nrf_sdk\components\ble\ble_services\ble_rscs_c;nrf_sdk\components\ble\ble_services\ble_tps;nrf_sdk\components\ble\common;nrf_sdk\components\ble\nrf_ble_gatt;nrf_sdk\components\ble\nrf_ble_qwr;nrf_sdk\components\ble\peer_manager;nrf_sdk\components\ble\ble_link_ctx_manager;nrf_sdk\components\libraries\atomic;nrf_sdk\components\libraries\atomic_fifo;nrf_sdk\components\libraries\atomic_flags;nrf_sdk\components\libraries\balloc;nrf_sdk\components\libraries\bootloader\ble_dfu;nrf_sdk\components\libraries\button;nrf_sdk\components\libraries\cli;nrf_sdk\components\libraries\crc16;nrf_sdk\components\libraries\crc32;nrf_sdk\components\libraries\crypto;nrf_sdk\components\libraries\csense;nrf_sdk\components\libraries\csense_drv;nrf_sdk\components\libraries\delay;nrf_sdk\components\libraries\ecc;nrf_sdk\components\libraries\experimental_section_vars;nrf_sdk\components\libraries\experimental_task_manager;nrf_sdk\components\libraries\fds;nrf_sdk\components\libraries\fstorage;nrf_sdk\components\libraries\gfx;nrf_sdk\components\libraries\gpiote;nrf_sdk\components\libraries\hardfault;nrf_sdk\components\libraries\hardfault\nrf52;nrf_sdk\components\libraries\hci;nrf_sdk\components\libraries\led_softblink;nrf_sdk\components\libraries\log;nrf_sdk\components\libraries\log\src;nrf_sdk\components\libraries\low_power_pwm;nrf_sdk\components\libraries\mem_manager;nrf_sdk\components\libraries\memobj;nrf_sdk\components\libraries\mpu;nrf_sdk\components\libraries\mutex;nrf_sdk\components\libraries\pwm;nrf_sdk\components\libraries\pwr_mgmt;nrf_sdk\components\libraries\queue;nrf_sdk\components\libraries\ringbuf;nrf_sdk\components\libraries\scheduler;nrf_sdk\components\libraries\sdcard;nrf_sdk\components\libraries\sensorsim;nrf_sdk\components\libraries\slip;nrf_sdk\components\libraries\sortlist;nrf_sdk\components\libraries\spi_mngr;nrf_sdk\components\libraries\stack_guard;nrf_sdk\components\libraries\strerror;nrf_sdk\components\libraries\svc;nrf_sdk\components\libraries\timer;nrf_sdk\components\libraries\twi_mngr;nrf_sdk\components\libraries\twi_sensor;nrf_sdk\components\libraries\usbd;nrf_sdk\components\libraries\usbd\class\audio;nrf_sdk\components\libraries\usbd\class\cdc;nrf_sdk\components\libraries\usbd\class\cdc\acm;nrf_sdk\components\libraries\usbd\class\hid;nrf_sdk\components\libraries\usbd\class\hid\generic;nrf_sdk\components\libraries\usbd\class\hid\kbd;nrf_sdk\components\libraries\usbd\class\hid\mouse;nrf_sdk\components\libraries\usbd\class\msc;nrf_sdk\components\libraries\util;nrf_sdk\components\nfc\ndef\conn_hand_parser;nrf_sdk\components\nfc\ndef\conn_hand_parser\ac_rec_parser;nrf_sdk\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;nrf_sdk\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;nrf_sdk\components\nfc\ndef\connection_handover\ac_rec;nrf_sdk\components\nfc\ndef\connection_handover\ble_oob_advdata;nrf_sdk\components\nfc\ndef\connection_handover\ble_pair_lib;nrf_sdk\components\nfc\ndef\connection_handover\ble_pair_msg;nrf_sdk\components\nfc\ndef\connection_handover\common;nrf_sdk\components\nfc\ndef\connection_handover\ep_oob_rec;nrf_sdk\components\nfc\ndef\connection_handover\hs_rec;nrf_sdk\components\nfc\ndef\connection_handover\le_oob_rec;nrf_sdk\components\nfc\ndef\generic\message;nrf_sdk\components\nfc\ndef\generic\record;nrf_sdk\components\nfc\ndef\launchapp;nrf_sdk\components\nfc\ndef\parser\message;nrf_sdk\components\nfc\ndef\parser\record;nrf_sdk\components\nfc\ndef\text;nrf_sdk\components\nfc\ndef\uri;nrf_sdk\components\nfc\platform;nrf_sdk\components\nfc\t2t_lib;nrf_sdk\components\nfc\t2t_parser;nrf_sdk\components\nfc\t4t_lib;nrf_sdk\components\nfc\t4t_parser\apdu;nrf_sdk\components\nfc\t4t_parser\cc_file;nrf_sdk\components\nfc\t4t_parser\hl_detection_procedure;nrf_sdk\components\nfc\t4t_parser\tlv;nrf_sdk\components\softdevice\common;nrf_sdk\components\softdevice\s132\headers;nrf_sdk\components\softdevice\s132\headers\nrf52;nrf_sdk\components\libraries\bootloader;nrf_sdk\components\libraries\bootloader\dfu;nrf_sdk\components\libraries\fifo;nrf_sdk\components\libraries\uart;nrf_sdk\external\fprintf;nrf_sdk\external\freertos\portable\ARM\nrf52;nrf_sdk\external\freertos\portable\CMSIS\nrf52;nrf_sdk\external\freertos\source\include;nrf_sdk\external\segger_rtt;nrf_sdk\external\utf_converter;nrf_sdk\external\cJSON;nrf_sdk\integration\nrfx;nrf_sdk\integration\nrfx\legacy;nrf_sdk\modules\nrfx;nrf_sdk\modules\nrfx\drivers\include;nrf_sdk\modules\nrfx\hal;nrf_sdk\modules\nrfx\mdk;board;applications;modules\ccm3310;modules\button;modules\at\include;modules\ringbuf;modules\ec800m;modules\ec800m\mqtt;modules\ec800m\socket;modules\max30102\v2;modules\max30102;services\gnss;services\at\include;services\ringbuf;services\mqttclient\common;services\mqttclient\config;services\mqttclient\mqtt;services\mqttclient\mqttclient;services\mqttclient\network;services\mqttclient\platform\FreeRTOS;.eide\deps;.cmsis\include
  asm define: CONFIG_GPIO_AS_PINRESET,FLOAT_ABI_HARD,FREERTOS,NRF52,NRF52832_XXAA,NRF52_PAN_74,NRF_SD_BLE_API_VERSION=7,S132,SOFTDEVICE_PRESENT,__HEAP_SIZE=1024,__STACK_SIZE=2048,BOARD_CUSTOM,USE_APP_CONFIG,AT_USING_CLIENT,MQTT_NETWORK_TYPE_NO_TLS
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x5a000
  memory RVCT9: RAM 0x20002b00 size 0xd500
  memory RVCT10: RAM 0x800000 size 0x10000
  group UTF8/UTF16 converter
    nrf_sdk/external/utf_converter/: utf.c
  group Third Parties
    nrf_sdk/external/freertos/portable/ARM/nrf52/: port.c
    nrf_sdk/external/freertos/portable/CMSIS/nrf52/: port_cmsis_systick.c port_cmsis.c
    nrf_sdk/external/freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    nrf_sdk/external/freertos/source/portable/MemMang/: heap_4.c
  group Services/ringbuf
    services/ringbuf/: ringbuf.c
  group Services/mqttclient
    services/mqttclient/common/: mqtt_list.c random.c
    services/mqttclient/mqttclient/: mqttclient.c
    services/mqttclient/network/: nettype_tcp.c nettype_tls.c network.c
  group Services/mqttclient/port
    services/mqttclient/platform/FreeRTOS/: platform_memory.c platform_mutex.c platform_net_socket.c platform_thread.c platform_timer.c
  group Services/mqttclient/paho-mqtt
    services/mqttclient/mqtt/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group Services/gnss
    services/gnss/: gps_rmc.c
  group Services/CJSON
    nrf_sdk/external/cJSON/: cJSON.c
  group Services/at
    services/at/src/: at_client.c at_utils.c
  group nRF_SoftDevice
    nrf_sdk/components/softdevice/common/: nrf_sdh_ble.c nrf_sdh_freertos.c nrf_sdh_soc.c nrf_sdh.c
  group nRF_Segger_RTT
    nrf_sdk/external/segger_rtt/: SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT.c
  group nRF_Log
    nrf_sdk/components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Libraries
    nrf_sdk/components/libraries/atomic_fifo/: nrf_atfifo.c
    nrf_sdk/components/libraries/atomic_flags/: nrf_atflags.c
    nrf_sdk/components/libraries/atomic/: nrf_atomic.c
    nrf_sdk/components/libraries/balloc/: nrf_balloc.c
    nrf_sdk/components/libraries/button/: app_button.c
    nrf_sdk/components/libraries/crc16/: crc16.c
    nrf_sdk/components/libraries/experimental_section_vars/: nrf_section_iter.c
    nrf_sdk/components/libraries/fds/: fds.c
    nrf_sdk/components/libraries/fifo/: app_fifo.c
    nrf_sdk/components/libraries/fstorage/: nrf_fstorage_sd.c nrf_fstorage.c
    nrf_sdk/components/libraries/hardfault/: hardfault_implementation.c
    nrf_sdk/components/libraries/hardfault/nrf52/handler/: hardfault_handler_keil.c
    nrf_sdk/components/libraries/memobj/: nrf_memobj.c
    nrf_sdk/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    nrf_sdk/components/libraries/ringbuf/: nrf_ringbuf.c
    nrf_sdk/components/libraries/sensorsim/: sensorsim.c
    nrf_sdk/components/libraries/strerror/: nrf_strerror.c
    nrf_sdk/components/libraries/timer/: app_timer_freertos.c
    nrf_sdk/components/libraries/uart/: app_uart_fifo.c retarget.c
    nrf_sdk/components/libraries/util/: app_error_handler_keil.c app_error_weak.c app_error.c app_util_platform.c nrf_assert.c
    nrf_sdk/external/fprintf/: nrf_fprintf_format.c nrf_fprintf.c
  group nRF_Drivers
    nrf_sdk/integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_uart.c
    nrf_sdk/modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_pwm.c nrfx_spi.c nrfx_spim.c nrfx_swi.c nrfx_twi_twim.c nrfx_twi.c nrfx_twim.c nrfx_uart.c nrfx_uarte.c
    nrf_sdk/modules/nrfx/drivers/src/prs/: nrfx_prs.c
    nrf_sdk/modules/nrfx/soc/: nrfx_atomic.c
  group nRF_DFU
    nrf_sdk/components/ble/ble_services/ble_dfu/: ble_dfu_bonded.c ble_dfu_unbonded.c ble_dfu.c
    nrf_sdk/components/libraries/bootloader/dfu/: nrf_dfu_svci.c
  group nRF_BLE_Services
    nrf_sdk/components/ble/ble_services/ble_bas/: ble_bas.c
    nrf_sdk/components/ble/ble_services/ble_dis/: ble_dis.c
    nrf_sdk/components/ble/ble_services/ble_hrs/: ble_hrs.c
    nrf_sdk/components/ble/ble_services/ble_nus/: ble_nus.c
  group nRF_BLE
    nrf_sdk/components/ble/ble_advertising/: ble_advertising.c
    nrf_sdk/components/ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
    nrf_sdk/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    nrf_sdk/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    nrf_sdk/components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
    nrf_sdk/components/ble/peer_manager/: auth_status_tracker.c gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data_storage.c peer_database.c peer_id.c peer_manager_handler.c peer_manager.c pm_buffer.c security_dispatcher.c security_manager.c
  group Modules/max30102
    modules/max30102/: max30102.c
    modules/max30102/v2/: algorithm_v2.c blood_v2.c
  group Modules/ec800m
    modules/ec800m/: ec800m_at_cmd.c ec800m.c
    modules/ec800m/mqtt/: ec800m_mqtt_at_urc.c ec800m_mqtt.c
    modules/ec800m/socket/: ec800m_socket_at_urc.c ec800m_socket.c
  group Modules/ccm3310
    modules/ccm3310/: ccm3310_nrf.c ccm3310_sm4.c crc32.c decode.c
  group Modules/button
    modules/button/: button.c
  group Libc
    services/libc/armcc/: ctime.c syscall_mem.c
  group Board
    applications/: bsp.c btn.c
    nrf_sdk/modules/nrfx/mdk/: arm_startup_nrf52.s system_nrf52.c
  group Application
    applications/: main.c
    board/: app_config.h FreeRTOSConfig.h sdk_config.h
  group Application/DFU
    services/ble_dfu/: ble_app_dfu.c
  group Application/APP
    applications/: app.c data_build.c data_wr.c mqtt_app.c
