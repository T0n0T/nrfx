# Keil uVision project nrf52832.uvprojx, settings and files
target rtthread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.32.1
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x00800000,0x00010000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NRF_LOG_BACKEND_RTT_ENABLED, __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, NRF52832_XXAA, SOFTDEVICE_PRESENT, NRFX_GPIOTE_ENABLED, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, NRFX_CLOCK_ENABLED, LFS_CONFIG=lfs_config.h, CONFIG_GPIO_AS_PINRESET, USE_APP_CONFIG
  c misc: --reduce_paths
  c include: nrf_sdk\components\libraries\memobj;rt-thread\components\net\sal\include\socket;nrf_sdk\components\ble\ble_advertising;rt-thread\components\net\sal\impl;packages\SEGGER_RTT-latest;nrf_sdk\components\libraries\atomic_flags;services\kawaii-mqtt\common;nrf_sdk\modules\nrfx\soc;rt-thread\components\libc\compilers\common\extension;nrf_sdk\modules\nrfx\mdk;services\littlefs;services\kawaii-mqtt\network;rt-thread\libcpu\arm\cortex-m4;nrf_sdk\components\libraries\strerror;nrf_sdk\modules\nrfx\drivers;rt-thread\components\libc\posix\io\poll;rt-thread\components\fal\inc;rt-thread\components\dfs\dfs_v1\filesystems\devfs;nrf_sdk\components\libraries\balloc;nrf_sdk\integration\nrfx\legacy;rt-thread\components\drivers\include;nrf_sdk\components\libraries\util;nrf_sdk\components\libraries\log;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;nrf_sdk\modules\nrfx;packages\CmBacktrace-v1.4.1;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\components\net\at\include;rt-thread\components\libc\posix\ipc;rt-thread\components\net\sal\include\dfs_net;rt-thread\components\net\netdev\include;rt-thread\components\finsh;modules\max30102;rt-thread\components\net\sal\include\socket\sys_socket;modules\button;nrf_sdk\components\libraries\delay;nrf_sdk\components\libraries\atomic;packages\SEGGER_RTT-latest\RTT;nrf_sdk\components\softdevice\common;nrf_sdk\components\softdevice\s132\headers\nrf52;libraries\drivers;nrf_sdk\components\libraries\log\src;nrf_sdk\components\ble\common;rt-thread\components\libc\compilers\common\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;nrf_sdk\components\ble\nrf_ble_qwr;rt-thread\components\drivers\include;services\kawaii-mqtt\common\log;rt-thread\components\utilities\resource;applications;rt-thread\libcpu\arm\common;services\kawaii-mqtt\mqttclient;rt-thread\components\drivers\include;libraries\cmsis\include;nrf_sdk\modules\nrfx\drivers\src;rt-thread\components\drivers\include;rt-thread\components\drivers\include;services\kawaii-mqtt\mqtt;rt-thread\components\drivers\include;rt-thread\components\legacy\dfs;board;rt-thread\components\libc\posix\io\epoll;nrf_sdk\components\ble\nrf_ble_gatt;nrf_sdk\modules\nrfx\hal;rt-thread\components\dfs\dfs_v1\include;modules\ccm3310;rt-thread\include;nrf_sdk\components\softdevice\s132\headers;rt-thread\components\legacy;nrf_sdk\components\libraries\experimental_section_vars;modules\ec800x;services\gnss;nrf_sdk\external\fprintf;rt-thread\components\net\at\at_socket;.;rt-thread\components\libc\posix\io\eventfd;packages\at_device-latest\inc;nrf_sdk\components\libraries\ringbuf;nrf_sdk\modules\nrfx\drivers\include;services\kawaii-mqtt\platform\RT-Thread;rt-thread\components\net\sal\include
  memory RVCT4: ROM 0x26000 size 0x5a000
  memory RVCT9: RAM 0x20004c00 size 0xb400
  group Applications
    applications/: main.c mnt.c
  group AT
    rt-thread/components/net/at/src/: at_client.c at_cli.c at_utils.c
    rt-thread/components/net/at/at_socket/: at_socket.c
  group at_device
    packages/at_device-latest/src/: at_device.c
  group button
    modules/button/: button.c
  group ccm3310
    modules/ccm3310/: ccm3310_test.c ccm3310_sm4.c crc32.c ccm3310.c decode.c ccm3310_nrf.c
  group cm_backtrace
    packages/CmBacktrace-v1.4.1/: cm_backtrace.c cmb_port.c cmb_flash_log.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/hwtimer/: hwtimer.c
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/mtd/: mtd_nor.c
    rt-thread/components/drivers/rtc/: rtc.c
    rt-thread/components/drivers/sensor/v1/: sensor.c sensor_cmd.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
  group Drivers
    board/: board.c sdk_config.h
    libraries/drivers/: drv_flash.c drv_gpio.c drv_hwtimer.c drv_i2c.c drv_rtc.c drv_spi.c drv_uarte.c
  group ec800x
    modules/ec800x/: at_socket_ec800x.c at_device_ec800x.c at_instance_ec800x.c
  group Fal
    rt-thread/components/fal/src/: fal_flash.c fal_rtt.c fal_partition.c fal.c
  group Filesystem
    rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group gps_rmc
    services/gnss/: gps_rmc.c
  group kawaii_mqtt
    services/kawaii-mqtt/network/: nettype_tcp.c nettype_tls.c network.c
    services/kawaii-mqtt/common/log/: fifo.c salof.c format.c
    services/kawaii-mqtt/platform/RT-Thread/: platform_thread.c platform_net_socket.c platform_timer.c platform_mutex.c platform_memory.c
    services/kawaii-mqtt/mqttclient/: mqttclient.c
    services/kawaii-mqtt/mqtt/: MQTTSubscribeServer.c MQTTConnectServer.c MQTTUnsubscribeServer.c MQTTPacket.c MQTTConnectClient.c MQTTSerializePublish.c MQTTDeserializePublish.c MQTTSubscribeClient.c MQTTFormat.c MQTTUnsubscribeClient.c
    services/kawaii-mqtt/common/log/arch/rt-thread/: arch.c
    services/kawaii-mqtt/common/: random.c mqtt_list.c
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Legacy
    rt-thread/components/legacy/ipc/: workqueue_legacy.c
  group littlefs
    services/littlefs/: lfs.c dfs_lfs.c lfs_util.c lfs_crc.c
  group max30102
    modules/max30102/: port.c max30102.c blood.c algorithm.c
  group nrf_ble
    nrf_sdk/components/ble/common/: ble_conn_state.c ble_srv_common.c ble_advdata.c
    nrf_sdk/components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
    nrf_sdk/rtthread_adapter/: ble_conn_params_rtt.c
    nrf_sdk/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    nrf_sdk/components/ble/ble_advertising/: ble_advertising.c
  group nrf_hal
    nrf_sdk/modules/nrfx/drivers/src/: nrfx_systick.c nrfx_pdm.c nrfx_uart.c nrfx_dppi.c nrfx_rng.c nrfx_spis.c nrfx_spim.c nrfx_power.c nrfx_usbd.c nrfx_twim.c nrfx_adc.c nrfx_timer.c nrfx_comp.c nrfx_nvmc.c nrfx_wdt.c nrfx_i2s.c nrfx_lpcomp.c nrfx_twi_twim.c nrfx_qspi.c nrfx_clock.c nrfx_spi.c nrfx_twi.c nrfx_pwm.c nrfx_uarte.c nrfx_temp.c nrfx_ppi.c nrfx_swi.c nrfx_qdec.c nrfx_gpiote.c nrfx_nfct.c nrfx_twis.c nrfx_rtc.c nrfx_saadc.c
    nrf_sdk/modules/nrfx/mdk/: arm_startup_nrf52.s system_nrf52.c
    nrf_sdk/integration/nrfx/legacy/: nrf_drv_clock.c
  group nrf_lib
    nrf_sdk/components/libraries/balloc/: nrf_balloc.c
    nrf_sdk/components/libraries/util/: app_error_weak.c app_util_platform.c app_error_handler_keil.c app_error.c
    nrf_sdk/components/libraries/memobj/: nrf_memobj.c
    nrf_sdk/external/fprintf/: nrf_fprintf_format.c nrf_fprintf.c
    nrf_sdk/components/libraries/atomic/: nrf_atomic.c
    nrf_sdk/components/libraries/ringbuf/: nrf_ringbuf.c
    nrf_sdk/components/libraries/atomic_flags/: nrf_atflags.c
    nrf_sdk/components/libraries/strerror/: nrf_strerror.c
    nrf_sdk/components/libraries/experimental_section_vars/: nrf_section_iter.c
  group nrf_log
    nrf_sdk/components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_backend_rtt.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nrf_softdev
    nrf_sdk/components/softdevice/common/: nrf_sdh.c nrf_sdh_soc.c nrf_sdh_ble.c
  group POSIX
    rt-thread/components/libc/posix/io/poll/: poll.c select.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    rt-thread/components/net/sal/dfs_net/: dfs_net.c
    rt-thread/components/net/sal/impl/: af_inet_at.c
    rt-thread/components/net/sal/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal/src/: sal_socket.c
  group SEGGER_RTT
    packages/SEGGER_RTT-latest/adapter/: drv_rtt.c
    packages/SEGGER_RTT-latest/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Utilities
    rt-thread/components/utilities/resource/: resource_id.c
target softdevice (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.32.1
  cpu: IRAM(0x20000000,0x40000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: s132_nrf52_7.0.1_softdevice.hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NRF52832_XXAA, USE_APP_CONFIG, RT_USING_ARM_LIBC  APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52832_XXAA NRF_SD_BLE_API_VERSION=7 S132 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  asm define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52832_XXAA NRF_SD_BLE_API_VERSION=7 S132 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192
  asm misc: --cpreproc_opts=-DAPP_TIMER_V2,-DAPP_TIMER_V2_RTC1_ENABLED,-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52832_XXAA,-DNRF_SD_BLE_API_VERSION=7,-DS132,-DSOFTDEVICE_PRESENT,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  memory RVCT4: ROM 0x27000 size 0xd9000
  memory RVCT9: RAM 0x20002300 size 0x40000
  link misc: --diag_suppress 6330
  group left out of the first target's files
    applications/: main.c mnt.c
    board/: board.c sdk_config.h
    libraries/drivers/: drv_flash.c drv_gpio.c drv_hwtimer.c drv_i2c.c drv_rtc.c drv_spi.c drv_uarte.c
    modules/button/: button.c
    modules/ccm3310/: ccm3310.c ccm3310_nrf.c ccm3310_sm4.c ccm3310_test.c crc32.c decode.c
    modules/ec800x/: at_device_ec800x.c at_instance_ec800x.c at_socket_ec800x.c
    modules/max30102/: algorithm.c blood.c max30102.c port.c
    nrf_sdk/components/ble/ble_advertising/: ble_advertising.c
    nrf_sdk/components/ble/common/: ble_advdata.c ble_conn_state.c ble_srv_common.c
    nrf_sdk/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    nrf_sdk/components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
    nrf_sdk/components/libraries/atomic/: nrf_atomic.c
    nrf_sdk/components/libraries/atomic_flags/: nrf_atflags.c
    nrf_sdk/components/libraries/balloc/: nrf_balloc.c
    nrf_sdk/components/libraries/experimental_section_vars/: nrf_section_iter.c
    nrf_sdk/components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
    nrf_sdk/components/libraries/memobj/: nrf_memobj.c
    nrf_sdk/components/libraries/ringbuf/: nrf_ringbuf.c
    nrf_sdk/components/libraries/strerror/: nrf_strerror.c
    nrf_sdk/components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c
    nrf_sdk/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
    nrf_sdk/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    nrf_sdk/integration/nrfx/legacy/: nrf_drv_clock.c
    nrf_sdk/modules/nrfx/drivers/src/: nrfx_adc.c nrfx_clock.c nrfx_comp.c nrfx_dppi.c nrfx_gpiote.c nrfx_i2s.c nrfx_lpcomp.c nrfx_nfct.c nrfx_nvmc.c nrfx_pdm.c nrfx_power.c nrfx_ppi.c nrfx_pwm.c nrfx_qdec.c nrfx_qspi.c nrfx_rng.c nrfx_rtc.c nrfx_saadc.c nrfx_spi.c nrfx_spim.c nrfx_spis.c nrfx_swi.c nrfx_systick.c nrfx_temp.c nrfx_timer.c nrfx_twi.c nrfx_twi_twim.c nrfx_twim.c nrfx_twis.c nrfx_uart.c nrfx_uarte.c nrfx_usbd.c nrfx_wdt.c
    nrf_sdk/modules/nrfx/mdk/: arm_startup_nrf52.s system_nrf52.c
    nrf_sdk/rtthread_adapter/: ble_conn_params_rtt.c
    packages/CmBacktrace-v1.4.1/: cm_backtrace.c cmb_flash_log.c cmb_port.c
    packages/SEGGER_RTT-latest/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    packages/SEGGER_RTT-latest/adapter/: drv_rtt.c
    packages/at_device-latest/src/: at_device.c
    rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/hwtimer/: hwtimer.c
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/mtd/: mtd_nor.c
    rt-thread/components/drivers/rtc/: rtc.c
    rt-thread/components/drivers/sensor/v1/: sensor.c sensor_cmd.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
    rt-thread/components/fal/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    rt-thread/components/finsh/: cmd.c msh.c msh_file.c msh_parse.c shell.c
    rt-thread/components/legacy/ipc/: workqueue_legacy.c
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    rt-thread/components/libc/posix/io/poll/: poll.c select.c
    rt-thread/components/net/at/at_socket/: at_socket.c
    rt-thread/components/net/at/src/: at_cli.c at_client.c at_utils.c
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    rt-thread/components/net/sal/dfs_net/: dfs_net.c
    rt-thread/components/net/sal/impl/: af_inet_at.c
    rt-thread/components/net/sal/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal/src/: sal_socket.c
    rt-thread/components/utilities/resource/: resource_id.c
    rt-thread/libcpu/arm/common/: div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_up.c thread.c timer.c
    services/gnss/: gps_rmc.c
    services/kawaii-mqtt/common/log/arch/rt-thread/: arch.c
    services/kawaii-mqtt/common/log/: fifo.c format.c salof.c
    services/kawaii-mqtt/common/: mqtt_list.c random.c
    services/kawaii-mqtt/mqtt/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
    services/kawaii-mqtt/mqttclient/: mqttclient.c
    services/kawaii-mqtt/network/: nettype_tcp.c nettype_tls.c network.c
    services/kawaii-mqtt/platform/RT-Thread/: platform_memory.c platform_mutex.c platform_net_socket.c platform_thread.c platform_timer.c
    services/littlefs/: dfs_lfs.c lfs.c lfs_crc.c lfs_util.c
